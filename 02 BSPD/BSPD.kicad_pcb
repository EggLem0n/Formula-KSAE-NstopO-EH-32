# Repository EggLem0n/Formula-KSAE-NstopO-EH-32

## KiCad design 02 BSPD/BSPD.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; C_Disc_D7.5mm_W2.5mm_P5.00mm
C5: 10uF; CP_Radial_D5.0mm_P2.00mm
D1: 1N5240B; D_DO-35_SOD27_P7.62mm_Horizontal
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
R1: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R6: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 15k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2: 10k; Potentiometer_Bourns_3386P_Vertical
U1, U2, U3, U4: LM393; DIP-8_W7.62mm_Socket

Connections:
+12V: C1.2, C2.2, C3.2, C4.2, D2.1 (K), J2.1, R1.1, R4.1, R5.2, R21.1, RV1.1, RV2.1, U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+)
BSPD_Fault: J1.3, R21.2, U2.1, U2.7, U3.1, U3.7, U4.1
Brake sensor: J1.1, U1.3 (+), U2.2 (-), U3.3 (+)
Current sensor: J1.2, U1.5 (+), U2.6 (-), U3.5 (+)
GND: C1.1, C2.1, C3.1, C4.1, C5.2, D1.2 (A), J2.3, R3.2, R6.1, RV1.3, RV2.3, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-)
unnamed: C5.1, D1.1 (K), D2.2 (A), R4.2, U1.1, U1.7, U4.2 (-)
unnamed: RV1.2, U1.2 (-)
unnamed: RV2.2, U1.6 (-)
unnamed: R1.2, R2.1, U2.3 (+), U2.5 (+)
unnamed: R2.2, R3.1, U3.2 (-), U3.6 (-)
unnamed: R5.1, R6.2, U4.3 (+)

Notes on the sheet:
기준값 설정
단선 방지 pin7 - High : Valid Low : Fault
단선 방지
BSPD fault signal pin3 - High : Valid Low : Fault
역젼류 방지
최대 전압 설정 pin1 - High : Valid Low : Fault
역전류 방지
단락 방지 pin7 - High : Valid Low : Fault
단락 방지
압력센서

Board: 2 copper layers, 100.0 x 80.0 mm, 26 parts (0 on the bottom side), 11 nets.

## KiCad design 07 CSC/CSC.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm
J1, J4: Conn_01x03_Pin; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
J2, J3: Conn_01x02_Pin; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
K1, K2: RT42xFxx; Relay_DPDT_Schrack-RT2-FormC-Dual-Coil_RM5mm
R5: 2,2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R10: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TP1, TP2, TP3: TestPoint; TestPoint_Keystone_5000-5004_Miniature
U1: ULN2003A; DIP-16_W7.62mm_Socket

Connections:
+12V: J1.1, K1.11, K1.21, K1.A3, K2.11, K2.A3, R6.2, R8.2, U1.9 (COM)
BMS_FAULT: J2.2, R6.1, TP1.1, U1.1 (I1)
BMS_LED: J4.1, K1.14
GND: J1.3, R5.2, R10.2, U1.8 (GND)
IMD_FAULT: J2.1, R5.1, TP2.1, U1.2 (I2)
IMD_LED: J4.3, K2.14
unnamed: K1.22, K2.21
unnamed: R8.1, U1.3 (I3), U1.15 (O2)
unnamed: K1.A2, U1.16 (O1)
unnamed: K2.A2, U1.14 (O3)
unnamed: K1.A1, K2.A1, U1.10 (O7)
RESET: J3.1, R10.1, U1.7 (I7)
SDC_END_out: J3.2, K2.22, TP3.1

Notes on the sheet:
IMD 데이터시트 권장값 풀다운 저항값 2.2k

Board: 2 copper layers, 100.0 x 80.0 mm, 18 parts (0 on the bottom side), 13 nets.

## KiCad design 08 TSAL LED/정방향/TSAL LED.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9: 5Pie Green; LED_Rectangular_W7.62mm_H4.55mm_P5.08mm_R3
D10, D11, D12, D13, D14, D15, D16, D17, D18: 5Pie Red; LED_Rectangular_W7.62mm_H4.55mm_P5.08mm_R3
J1: Conn_01x04_Pin; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
R1, R2, R3: 200; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R4, R5, R6: 300; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal

Connections:
+14.4V: J1.1, R4.2, R5.1, R6.1
GND: D3.1 (K), D6.1 (K), D9.1 (K), J1.4
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D4.2 (A), R2.2
unnamed: D4.1 (K), D5.2 (A)
unnamed: D5.1 (K), D6.2 (A)
unnamed: D7.2 (A), R3.2
unnamed: D7.1 (K), D8.2 (A)
unnamed: D8.1 (K), D9.2 (A)
unnamed: D10.2 (A), R4.1
unnamed: D10.1 (K), D11.2 (A)
unnamed: D11.1 (K), D12.2 (A)
unnamed: D13.2 (A), R5.2
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D15.2 (A)
unnamed: D16.2 (A), R6.2
unnamed: D16.1 (K), D17.2 (A)
unnamed: D17.1 (K), D18.2 (A)
TSAL_Green: J1.3, R1.1, R2.1, R3.1
TSAL_RED: D12.1 (K), D15.1 (K), D18.1 (K), J1.2

Board: 2 copper layers, 121.0 x 35.1 mm, 25 parts (0 on the bottom side), 22 nets.
