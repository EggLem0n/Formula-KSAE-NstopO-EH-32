# Repository EggLem0n/Formula-KSAE-NstopO-EH-32

File README.md:

# E-Formula / EH-32-LV (KSAE)
This repository contains the LV Electrical Safety System Circuit Design files for the EH-32, developed by NstopO, the student racing team at Chung-Ang University. Please feel free to reach out if you have any questions.

## KiCad design 06 DisC/DisC.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.5mm
J1: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J2: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
K2: G2RL-1; Relay_SPDT_Omron_G2RL-1
R1: HSA505K6J, 5.6k; R_Axial_Power_L60.0mm_W14.0mm_P66.04mm

Connections:
Controller B+: J2.2, R1.1
GND: J1.1, K2.A2
unnamed: K2.11, R1.2
SDC: J1.2, K2.A1
controller B-: J2.1, K2.12

Board: 2 copper layers, 80.0 x 80.0 mm, 10 parts (0 on the bottom side), 5 nets.

## KiCad design 03 RTD+APPS/RTD+APPS.kicad_pcb

Parts:
C1: 0.1uF; C_Disc_D7.5mm_W2.5mm_P5.00mm
D1: 1N4148; D_DO-41_SOD81_P10.16mm_Horizontal
D2: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm
IC1: CD4066BE; DIP-14_W7.62mm; Manufacturer_Part_Number CD4066BE; Mouser Part Number 595-CD4066BE
J1, J3: Conn_01x04_Pin; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
J2: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
K1, K2: HR-CR7 DC12; Manufacturer_Part_Number JW1FSN-DC12V; Mouser Part Number 769-JW1FSN-DC12V
R1, R2: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R5, R6, R11, R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 75k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
T1: NE555_TIMER; HAM1227_molex5267_conn_fine
TP1, TP2, TP3: TestPoint; TestPoint_Keystone_5000-5004_Miniature
U1: LM393; DIP-8_W7.62mm
U3: ULN2003A; DIP-16_W7.62mm

Connections:
+12V: C1.2, J2.1, K2.1 (COIL_1), R3.2, R4.2, R7.2, T1.1 (12V_DC+), T1.3 (COM), U1.8 (V+), U3.9 (COM)
BRAKE_Sout: IC1.13 (CONTROL_A), J1.4, R5.1, TP2.1
BUZZER_in: J3.2, T1.4 (NC)
BUZZER_out: J3.3, U3.15 (O2)
Controller Ain+: J3.1, K2.4 (N.O.), TP3.1
GND: C1.1, D2.2 (A), IC1.7 (VSS), J2.3, K1.2 (COIL_2), R1.2, R2.2, R5.2, R6.2, R9.2, U1.4 (V-), U3.8 (GND)
unnamed: D1.2 (A), IC1.10 (SIG_D_OUT/IN), R11.2
unnamed: IC1.5 (CONTROL_B), R3.1, U1.1
unnamed: IC1.6 (CONTROL_C), R4.1, U1.7
unnamed: IC1.4 (SIG_B_IN/OUT), IC1.9 (SIG_C_OUT/IN)
unnamed: IC1.8 (SIG_C_IN/OUT), R12.2
unnamed: K1.4 (N.O.), K2.3 (COM)
unnamed: K2.2 (COIL_2), U3.10 (O7)
unnamed: T1.2 (12V_DC-), U3.16 (O1)
unnamed: R7.1, R8.1, U1.3 (+)
unnamed: R8.2, R9.1, U1.6 (-)
unnamed: R1.1, R11.1, U3.1 (I1), U3.2 (I2)
unnamed: R2.1, R12.1, U3.7 (I7)
RTD_in: IC1.2 (SIG_A_OUT/IN), J1.2
RTD_out: D1.1 (K), IC1.12 (CONTROL_D), J1.1, R6.1
RUN: D2.1 (K), J3.4, K1.1 (COIL_1), T1.5 (NO)
SDC_END_out: IC1.1 (SIG_A_IN/OUT), IC1.3 (SIG_B_OUT/IN), IC1.11 (SIG_D_IN/OUT), IC1.14 (VDD), J2.2
Trottle_out: J1.3, K1.3 (COM), TP1.1, U1.2 (-), U1.5 (+)

Board: 4 copper layers, 100.0 x 80.0 mm, 30 parts (0 on the bottom side), 23 nets.

## KiCad design 08 TSAL LED/대칭/TSAL LED Symmetry.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9: 5Pie Green; LED_Rectangular_W7.62mm_H4.55mm_P5.08mm_R3
D10, D11, D12, D13, D14, D15, D16, D17, D18: 5Pie Red; LED_Rectangular_W7.62mm_H4.55mm_P5.08mm_R3
J1: Conn_01x04_Pin; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
R1, R2, R3: 200; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R4, R5, R6: 300; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal

Connections:
+14.4V: J1.1, R4.2, R5.1, R6.1
GND: D3.1 (K), D6.1 (K), D9.1 (K), J1.4
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D4.2 (A), R2.2
unnamed: D4.1 (K), D5.2 (A)
unnamed: D5.1 (K), D6.2 (A)
unnamed: D7.2 (A), R3.2
unnamed: D7.1 (K), D8.2 (A)
unnamed: D8.1 (K), D9.2 (A)
unnamed: D10.2 (A), R4.1
unnamed: D10.1 (K), D11.2 (A)
unnamed: D11.1 (K), D12.2 (A)
unnamed: D13.2 (A), R5.2
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D15.2 (A)
unnamed: D16.2 (A), R6.2
unnamed: D16.1 (K), D17.2 (A)
unnamed: D17.1 (K), D18.2 (A)
TSAL_Green: J1.3, R1.1, R2.1, R3.1
TSAL_RED: D12.1 (K), D15.1 (K), D18.1 (K), J1.2

Board: 2 copper layers, 121.0 x 35.1 mm, 25 parts (0 on the bottom side), 22 nets.

## KiCad design 01 SDC/SDC.kicad_pcb

Parts:
C1: 10uF
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm
J1, J2: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J3: Conn_01x05_Pin; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
K1, K2, K3: RT42xFxx; Relay_DPDT_Schrack-RT2-FormC-Dual-Coil_RM5mm
R5: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R10: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Keystone_5000-5004_Miniature
U1: ULN2003A; DIP-16_W7.62mm_Socket

Connections:
+12V: J1.1, K1.11, K1.A3, K2.11, K2.A3, K3.11, K3.A3, R6.2, R7.2, R8.2, U1.9 (COM)
+LV: J1.2, K1.21
BMS_FAULT: J2.1, R6.1, TP3.1, U1.1 (I1)
BMS_LED: J3.5, K1.14
BSPD_FAULT: C1.1, J2.3, TP1.1, U1.4 (I4); also elsewhere on the board
BSPD_LED: J3.3, K3.14
GND: C1.2, J1.3, R5.2, R10.2, U1.8 (GND); also elsewhere on the board
IMD_FAULT: J2.2, R5.1, TP2.1, U1.2 (I2)
IMD_LED: J3.4, K2.14
unnamed: K1.22, K2.21
unnamed: K2.22, K3.21
unnamed: R8.1, U1.3 (I3), U1.15 (O2)
unnamed: R7.1, U1.5 (I5), U1.13 (O4)
unnamed: K1.A2, U1.16 (O1)
unnamed: K2.A2, U1.14 (O3)
unnamed: K3.A2, U1.12 (O5)
unnamed: K1.A1, K2.A1, K3.A1, U1.10 (O7)
RESET: J3.1, R10.1, U1.7 (I7)
SDC_END_out: J3.2, K3.22, TP4.1

Notes on the sheet:
IMD 데이터시트 권장값 풀다운 저항값 2.2k

Board: 4 copper layers, 100.0 x 80.0 mm, 21 parts (0 on the bottom side), 19 nets.

Other parts of the board:
R4: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Their connections:
BSPD_FAULT: R4.1; also elsewhere on the board
GND: R4.2; also elsewhere on the board

## KiCad design 00 차단회로도/SDC.kicad_pcb

Board: 4 copper layers, 100.0 x 80.0 mm, 45 parts (0 on the bottom side), 24 nets.

Parts:
D1, D2, D3, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D5, D6, D7: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: SN74HC04N; DIP794W53P254L1930H508Q14N
IC2: CD4044BE; DIP794W53P254L1930H508Q16N
IC3, IC4, IC5: AQV214; DIP762W47P254L880H410Q6N
J0, J1, J2, J3, J6: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J4, J5: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
K1, K2, K3: JS1-5V-F; JS1-12V-F_1
K4: G5Q-1A; Relay_SPST_Omron-G5Q-1A
R1, R3, R5, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R4, R6: 5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Keystone_5000-5004_Miniature

Connections:
+5V: IC1.14 (VCC), IC2.5 (ENABLE), IC2.16 (VDD), IC3.6 (D2), IC4.6 (D2), IC5.6 (D2), J6.1
BMS_FAULT: IC1.13 (6A), J3.1, R8.2
BMS_LED: D7.2 (A), J5.2, R11.2
BSPD_FAULT: J1.1, R1.2, R2.2, TP1.1
BSPD_LED: D5.2 (A), J5.3, R9.2
GND: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), IC1.7 (GND), IC2.8 (VSS), IC3.2 (K), IC4.2 (K), IC5.2 (K), J0.2, J1.2, J2.2, J3.2, J6.2, K1.5 (COIL_2), K2.5 (COIL_2), K3.5 (COIL_2), K4.1, R1.1, R3.1, R5.1, R7.1, R8.1
IMD_FAULT: J2.1, R3.2, R4.2, TP2.1
IMD_LED: D6.2 (A), J5.1, R10.2
unnamed: D1.1 (K), IC2.3 (S1), IC3.5 (S), K1.2 (COIL_1)
unnamed: D2.1 (K), IC2.7 (S2), IC4.5 (S), K2.2 (COIL_1)
unnamed: D3.1 (K), IC2.11 (S3), IC5.5 (S), K3.2 (COIL_1)
unnamed: IC1.10 (5Y), IC2.4 (R1), IC2.6 (R2), IC2.12 (R3)
unnamed: IC1.12 (6Y), R5.2, R6.2, TP3.1
unnamed: IC2.13 (Q1), R9.1
unnamed: IC2.9 (Q2), R10.1
unnamed: IC2.10 (Q3), R11.1
unnamed: IC3.1 (A), R2.1
unnamed: IC4.1 (A), R4.1
unnamed: IC5.1 (A), R6.1
unnamed: K1.3 (NC_1), K2.1 (COM), TP4.1
unnamed: K2.3 (NC_1), K3.1 (COM), TP5.1
RESET_in: J4.1, K3.3 (NC_1), K4.3, TP6.1
RESET_out: D4.1 (K), IC1.11 (5A), J4.2, J4.3, K4.2, K4.5, R7.2, TP7.1
VCC_SDC: J0.1, K1.1 (COM)

## KiCad design 05 TSAL/TSAL.kicad_pcb

Parts:
C1: 0.1uF; C_Disc_D7.5mm_W2.5mm_P5.00mm
C2: 1uF; CP_Radial_D5.0mm_P2.00mm
H1, H2, H3, H4: MountingHole; MountingHole_3.5mm
J1: Conn_01x05_Pin; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
J2, J3: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
K5: JW1FSN-DC12V; Manufacturer_Part_Number JW1FSN-DC12V; Mouser Part Number 769-JW1FSN-DC12V
R2, R8: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 200k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RL1: JW2; Relay_DPDT_Panasonic_JW2
U1: NE555P; DIP-8_W7.62mm
U2: ULN2003A; DIP-16_W7.62mm_Socket

Connections:
60V_HIGH_GREEN: J1.5, R2.1, U2.1 (I1)
60V_HIGH_RED: J1.4, R8.1, U2.3 (I3)
+12V: J1.2, K5.2 (COIL_2), K5.3 (COM), R2.2, R8.2, RL1.8, U2.9 (COM)
+LV: J1.1, RL1.6
GND: C1.2, C2.2, J1.3, RL1.3, U1.1 (GND), U2.8 (GND)
unnamed: K5.1 (COIL_1), U2.14 (O3)
unnamed: C1.1, K5.5 (N.C), R5.1, U1.4 (R), U1.8 (VCC)
unnamed: R5.2, R6.2, U1.7 (DIS)
unnamed: U1.3 (Q), U2.6 (I6)
unnamed: C2.1, R6.1, U1.2 (TR), U1.6 (THR)
unnamed: RL1.1, U2.16 (O1)
TSAL_Green_in: J2.2, RL1.5
TSAL_Green_out: J2.1, RL1.4
TSAL_RED: J3.1, J3.2, U2.11 (O6)
